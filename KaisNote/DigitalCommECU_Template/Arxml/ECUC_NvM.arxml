<AUTOSAR> <!-- NvM Configuration --> </AUTOSAR>