<AUTOSAR> <!-- SWC Definition --> </AUTOSAR>